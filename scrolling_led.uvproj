# Keil uVision project scrolling_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: scrolling_led
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c main_scrolling.c scrolling_led_fun.c
